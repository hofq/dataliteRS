## sdkconfig.defaults
```kconfig
CONFIG_LWIP_IPV4_NAPT=y
CONFIG_ESP_WIFI_SOFTAP_SUPPORT=y
CONFIG_ESP_MAIN_TASK_STACK_SIZE=16384
```
